Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: 0001
Time: 2023-10-31T12:20:36
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Alternate UI 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 31 12:20:36 2023 * Host: LAPTOP-RP8DN0OA * Database: C:\Users\claud\AppData\Local\Temp\{7EC12396-94FB-4941-9689-53E80823513B}\ifc * Database version: 5507 * Database creation date: Tue Oct 31 12:20:34 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 31 12:20:35 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 31 12:20:35 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 m
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey, 0 - Piano Terra
LongName: 0 - Piano Terra; Elevation: 0 m
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello: Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Altro - Categoria: Livelli; Famiglia: Livello: Livello; Famiglia e tipo: Livello: Livello; ID tipo: Livello: Livello; Tipo: Livello: Livello
Dati identità - Nome: 0 - Piano Terra; Piano edificio: yes; Strutturale: no
Dimensioni - Altezza di calcolo: 0 m
Vincoli - Quota altimetrica: 0 m
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Dati identità(Type) - Nome del tipo: Livello

# IfcBuildingElementProxy: 0PAAR160 - WITHOUT LEVELLING - VERDE ALPI, Panca DEMETRA 2DWS:0PAAR160 - WITHOUT LEVELLING - VERDE ALPI:160106
In: 0 - Piano Terra
Type - Material: PIASTRE, CONIFERA, VERDE ALPI
Type - Altro - Categoria: Modelli generici; Nome famiglia: Panca DEMETRA 2DWS
Type - Dati identità - BIM Name: DEMETRA 2DWS SENZA LIVELLAMENTO; BIM Object Type: PANCHINE - BENCHES; Code: 0PAAR160; Designer: BELLITALIA DESIGN; Family Name: DEMETRA; Nome del tipo: 0PAAR160 - WITHOUT LEVELLING - VERDE ALPI; URL Eng: https://www.bellitalia.net/en/products/benches/demetra-d/; URL Ita: https://www.bellitalia.net/prodotti/panchine/demetra-d/
Type - Dimensioni - Dimensions: 1800 mm x 600 mm x h 480 mm H 812 mm
Type - Generale - Descrizione Tecnica Famiglia: "Panca lineare modulare mod. “DEMETRA” 2DWS costituita da una seduta monolitica con seduta e schienale integrati. La seduta è dotata di un apposito scanso sulla quale è innestato un sistema di doghe longitudinali che offrono comfort sia a climi caldi che freddi."; Descrizione Tecnica per Codice: DEMETRA 2DWS SENZA SISTEMA DI LIVELLAMENTO BANCO VERDE ALPI CERCHI SUPERIORI SABBIATI BOCCIARDATI CON VERNICE ANTIDECADIMENTO E SEDUTA IN LEGNO DI CONIFERA; Fissaggio: Appoggio; Fixings: Freestanding; Technical Description Family: "Modular linear bench mod. “DEMETER” 2DWS consisting of a monolithic seat with seat and integrated backrest. The seat is equipped with a special recess on which a system of longitudinal slats is inserted, which offer comfort in both hot and cold climates."; Technical Description for Article: DEMETRA 2DWS WITHOUT LEVELLING SYSTEM BENCH IN GREEN ALPS SANDBLASTED WITH BUSH-HAMMERED UPPER RIMS ANTI-DECAY VARNISH AND CONIFER WOOD SEAT
Type - Materiali e finiture - MATERIALE PIASTRE: PIASTRE; Materiale Principale: Pietre Preziose Ricostituite Verde Alpi; Materiale Secondario: Pietre Preziose Ricostituite; Legno Conifera; MATERIALE SEDUTA: CONIFERA; MATERIALE SUPPORTO: VERDE ALPI; Primary Material: Green Alps Reconstituted Precious Stones; Secondary Material: Reconstituted Precious Stone; Coniferous wood
Type - Meccanica - Weight ( kg): 812 mm
Pset_BuildingElementProxyCommon - Reference: 0PAAR160 - WITHOUT LEVELLING - VERDE ALPI
Altro - Famiglia: Panca DEMETRA 2DWS: 0PAAR160 - WITHOUT LEVELLING - VERDE ALPI; Famiglia e tipo: Panca DEMETRA 2DWS: 0PAAR160 - WITHOUT LEVELLING - VERDE ALPI; ID tipo: Panca DEMETRA 2DWS: 0PAAR160 - WITHOUT LEVELLING - VERDE ALPI; Tipo: Panca DEMETRA 2DWS: 0PAAR160 - WITHOUT LEVELLING - VERDE ALPI
Dimensioni - Area: 5.1549 m2; Volume: 0.485239 m3
Fasi - Fase di creazione: Stato di Progetto
Vincoli - Host: Livello : 0 - Piano Terra; Livello: Livello: 0 - Piano Terra; Offset: 0 m; Sposta con l'oggetto più vicino: no
